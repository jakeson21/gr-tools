options:
  parameters:
    author: fuguru
    generate_options: qt_gui
    id: stereo_audio_file_fm_tx
    output_language: python
    title: FM TX From Audio File
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    start: 80e6
    step: '100000'
    stop: 200e6
    value: 108.5e6
  states: {}
- name: fm_deviation
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: fm_deviation
    start: '2500'
    step: '500'
    stop: '100000'
    value: '50000'
  states: {}
- name: mono_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: L+R
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.9'
  states: {}
- name: out_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Out
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.95'
  states: {}
- name: pilot_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Pilot
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: stereo_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: L-R
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.9'
  states: {}
- name: variable_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '70'
    value: '45'
  states: {}
- name: analog_fm_preemph_0_0_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate
    tau: '50e-6'
  states: {}
- name: analog_fm_preemph_0_0_0_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate
    tau: '50e-6'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*np.pi*fm_deviation/(samp_rate*4*2)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2.0'
    freq: 2*19000.
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*4
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: pilot_gain
    comment: Pilot Tone
    freq: '19000.'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*4
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '95000'
    decim: '1'
    gain: out_gain
    samp_rate: samp_rate*4*2
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: mono_gain
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: stereo_gain
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*4*2
    fc: '0'
    fftsize: '1024'
    type: float
    ymax: '0'
    ymin: '-150'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*4*2
    fc: '0'
    fftsize: '1024'
    type: complex
    ymax: '30'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: samp_rate*4*2
    type: complex
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: rational_resampler_xxx_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    type: fff
  states: {}
- name: tools_audio_file_source_0
  id: tools_audio_file_source
  parameters:
    channels: '2'
    file_name: '''/home/fuguru/Music/Queensryche - 11 - Anybody Listening-.mp3'''
    normalize: 'True'
    repeat: 'True'
    samp_rate_out: samp_rate
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '500000'
    center_freq0: uhd.tune_request(center_freq, 0)
    dev_addr: '"serial=3102419"'
    gain0: variable_gain
    samp_rate: samp_rate*4*2
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: L_plus_R
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: L_minus_R
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: L_plus_R
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: L_minus_R
  states: {}

connections:
- [analog_fm_preemph_0_0_0, '0', blocks_add_xx_0_0, '0']
- [analog_fm_preemph_0_0_0, '0', blocks_sub_xx_0_0, '0']
- [analog_fm_preemph_0_0_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_fm_preemph_0_0_0_0, '0', blocks_sub_xx_0_0, '1']
- [analog_frequency_modulator_fc_0, '0', low_pass_filter_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0_0_0, '2']
- [blocks_add_xx_0_0, '0', rational_resampler_xxx_0_1_0, '0']
- [blocks_add_xx_0_0_0, '0', rational_resampler_xxx_0_1_0_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0_0_0, '1']
- [blocks_sub_xx_0_0, '0', rational_resampler_xxx_0_1_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0_0, '0', uhd_usrp_sink_0, '0']
- [low_pass_filter_0_1, '0', analog_fm_preemph_0_0_0, '0']
- [low_pass_filter_0_1_0, '0', analog_fm_preemph_0_0_0_0, '0']
- [rational_resampler_xxx_0_1_0, '0', virtual_sink_0_0, '0']
- [rational_resampler_xxx_0_1_0_0, '0', virtual_sink_0_0_0, '0']
- [rational_resampler_xxx_0_1_0_0_0, '0', analog_frequency_modulator_fc_0, '0']
- [rational_resampler_xxx_0_1_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [tools_audio_file_source_0, '0', low_pass_filter_0_1, '0']
- [tools_audio_file_source_0, '1', low_pass_filter_0_1_0, '0']
- [virtual_source_0_0, '0', blocks_add_xx_0_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
