options:
  parameters:
    category: '[AMR]'
    generate_options: qt_gui
    id: general_fsk_demod
    output_language: python
    title: FSK Demod
  states: {}

blocks:
- name: mag_trigger_level_0
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,1,1,1]'
    label: Mag Trigger Level
    start: '-90'
    step: '1'
    stop: '30'
    value: '-40'
  states: {}
- name: variable_qtgui_Fc
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,0,1,1]'
    label: Center Frequency Hz
    start: 400e6
    step: '1000'
    stop: 500e6
    value: 453.151e6
  states: {}
- name: variable_qtgui_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,0,1,1]'
    label: Gain
    start: '0'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: mag_trigger_level_0
    init: '0'
    low: mag_trigger_level_0-5
  states: {}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '4096'
    srate: samp_rate/2
    tr_level: mag_trigger_level_0
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: Magnitude
    ymax: '30'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '2'
    size: '4096'
    srate: samp_rate/2
    tr_chan: '1'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: Phase
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    fbw: '.4'
    interp: '1'
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '200000'
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: uhd.tune_request(variable_qtgui_Fc, samp_rate)
    dc_offs_enb0: auto
    dev_addr: '"serial=3102419"'
    gain0: variable_qtgui_Fc
    iq_imbal_enb0: auto
    minoutbuf: '1000'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_magphase_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_diff_phasor_cc_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_threshold_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_0, '1']
- [digital_diff_phasor_cc_0, '0', blocks_complex_to_magphase_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_1, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
