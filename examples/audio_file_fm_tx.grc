options:
  parameters:
    author: fuguru
    generate_options: qt_gui
    id: audio_file_fm_tx
    output_language: python
    title: FM TX From Audio File
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_center_freq
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    start: 150e6
    step: '10000'
    stop: 1e9
    value: 900.5e6
  states: {}
- name: variable_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '70'
    value: '25'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '44100'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: 2*44100
    tau: '75e-6'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    comment: 44100 * 160 / 147 = 48000
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: 44100*2 * 160 / 147 = 96000
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: 96000 * 2 = 192000
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '147'
    fbw: '0.4'
    interp: '160'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: '2'
    type: ccc
  states: {}
- name: tools_audio_file_source_0
  id: tools_audio_file_source
  parameters:
    channels: '2'
    file_name: '''/home/fuguru/Music/311-beautiful_disaster.mp3'''
    normalize: 'True'
    repeat: 'True'
    samp_rate_out: '41000'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: ''
    center_freq0: variable_center_freq
    dev_addr: '"serial=3102419"'
    gain0: variable_gain
    samp_rate: 96000*2
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', uhd_usrp_sink_0, '0']
- [tools_audio_file_source_0, '0', blocks_add_xx_0, '0']
- [tools_audio_file_source_0, '1', blocks_add_xx_0, '1']

metadata:
  file_format: 1
