options:
  parameters:
    author: Jacob Miller
    generate_options: qt_gui
    id: modulator
    output_language: python
    title: FM Modulator Example
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 900.5e6
  states: {}
- name: fd
  id: variable
  parameters:
    value: '1944'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '25'
  states: {}
- name: rrc_filter_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: sps*2/np.pi
    ntaps: 20*sps+1
    samp_rate: symb_rate*sps
    sym_rate: symb_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: samp_rate2
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1+0j, -1/3+0j, 1/3+0j, 1+0j]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '4'
    minimum: '0'
    minoutbuf: '1000'
    seed: '0'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: 1/20
    freq: '1'
    offset: '-0.5/20'
    phase: '0'
    samp_rate: symb_rate*sps
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '2'
    l: '8'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: np.stack((1*np.ones((int(100),), dtype=np.int32), 3*np.ones((int(100),), dtype=np.int32))).flatten()
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/fuguru/gnuradio/voice_1_48k.wav
    repeat: 'True'
  states: {state: disabled}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    nthreads: '2'
    taps: rrc_filter_taps
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate2
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: symb_rate*sps
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate2/symb_rate/sps)
    type: ccc
  states: {}
- name: tools_apsk_modulator_0
  id: tools_apsk_modulator
  parameters:
    constellation: np.array([648, 1944, -648, -1944]) /1944
    type: bf
  states: {}
- name: tools_fm_modulator_fc_0
  id: tools_fm_modulator_fc
  parameters:
    freq_deviation: '9600'
    initial_phase: '0'
    samp_rate: symb_rate*sps
  states: {}
- name: tools_upsample_xx_0
  id: tools_upsample_xx
  parameters:
    N: sps
    type: ff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate2
    center_freq0: center_freq
    dev_addr: '"serial=3102419"'
    gain0: rf_gain
    samp_rate: samp_rate2
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_random_uniform_source_x_0, '0', tools_apsk_modulator_0, '0']
- [analog_sig_source_x_0, '0', fft_filter_xxx_0, '0']
- [blocks_vector_source_x_0, '0', tools_apsk_modulator_0, '0']
- [blocks_wavfile_source_0, '0', tools_fm_modulator_fc_0, '0']
- [fft_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [fft_filter_xxx_0, '0', tools_fm_modulator_fc_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']
- [tools_apsk_modulator_0, '0', tools_upsample_xx_0, '0']
- [tools_fm_modulator_fc_0, '0', rational_resampler_xxx_0, '0']
- [tools_upsample_xx_0, '0', fft_filter_xxx_0, '0']

metadata:
  file_format: 1
