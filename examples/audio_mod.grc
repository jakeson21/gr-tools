options:
  parameters:
    author: fuguru
    generate_options: qt_gui
    id: mod_test
    output_language: python
    title: Modulator Testing
  states: {}

blocks:
- name: fd
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '1'
    gain: '1.0'
    samp_rate: '5'
    width: '0.125'
    win: window.WIN_BLACKMAN
  states: {state: disabled}
- name: rf_gain
  id: variable
  parameters:
    value: '25'
  states: {}
- name: rrc_filter_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: sps*2/np.pi
    ntaps: 20*sps+1
    samp_rate: sps
    sym_rate: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/symb_rate)
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: samp_rate/10
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1+0j, -1/3+0j, 1/3+0j, 1+0j]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: variable_qtgui_dial_control_0
  id: variable_qtgui_dial_control
  parameters:
    label: FM Deviation
    maximum: samp_rate/2
    minimum: '1000'
    minsize: '50'
    showvalue: 'True'
    type: real
    value: samp_rate/2
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '4'
    minimum: '0'
    minoutbuf: '1000'
    seed: '0'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: 2/sps
    freq: symb_rate/1000/10
    offset: '-1/sps'
    phase: '0'
    samp_rate: symb_rate*sps
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '2'
    l: '8'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: np.concatenate([[0]*500,[3]*500]).flatten()
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: np.concatenate([[0]*100,[3]*100]).flatten()
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: sps
    sensitivity: '0.15'
    verbose: 'True'
  states: {state: disabled}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: sps
    verbose: 'True'
  states: {state: disabled}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    nthreads: '2'
    taps: rrc_filter_taps
    type: fff
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import scipy.signal
  states: {}
- name: pfb_synthesizer_ccf_0
  id: pfb_synthesizer_ccf
  parameters:
    bus_conns: '[[0,],]'
    ch_map: '[0, 2, 3]'
    connections: '3'
    numchans: '5'
    taps: lpf_taps
    twox: 'False'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: symb_rate*sps/4
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: FSK
    type: complex
    ymin: '-90'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: symb_rate*sps/4
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: GFSK
    type: complex
    ymin: '-90'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: symb_rate*sps/4
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: GMSK
    type: complex
    ymin: '-90'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: symb_rate*sps/4*3
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: Channelized
    type: complex
    ymin: '-120'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: symb_rate*sps/4
    type: complex
    ymax: '2'
    ymin: '-2'
    yunit: FSK
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: symb_rate*sps/4
    type: complex
    ymax: '2'
    ymin: '-2'
    yunit: GFSK
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: symb_rate*sps/4
    type: complex
    ymax: '2'
    ymin: '-2'
    yunit: GMSK
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '256'
    int_max: '0'
    int_min: '-90'
    name: FSK
    type: complex
    update_time: '0.01'
    wintype: window.WIN_FLATTOP
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: symb_rate*sps/4
    fc: '0'
    fftsize: '256'
    int_max: '0'
    int_min: '-90'
    name: GFSK
    type: complex
    update_time: '0.01'
    wintype: window.WIN_FLATTOP
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: symb_rate*sps/4
    fc: '0'
    fftsize: '256'
    int_max: '0'
    int_min: '-90'
    name: GMSK
    type: complex
    update_time: '0.01'
    wintype: window.WIN_FLATTOP
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*5
    fc: '0'
    fftsize: '2048'
    int_max: '0'
    int_min: '-90'
    name: Channelized
    type: complex
    update_time: '0.01'
    wintype: window.WIN_FLATTOP
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '147'
    fbw: '0.4'
    interp: '160'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: '5'
    type: ccc
  states: {}
- name: tools_apsk_modulator_0
  id: tools_apsk_modulator
  parameters:
    constellation: 'np.array([-1944, 648,-648, 1944]) /1944 '
    type: bf
  states: {state: disabled}
- name: tools_audio_file_source_0
  id: tools_audio_file_source
  parameters:
    channels: '2'
    file_name: '''/home/fuguru/Music/311-beautiful_disaster.mp3'''
    repeat: 'True'
    samp_rate_out: '41000'
  states: {}
- name: tools_fm_modulator_fc_0
  id: tools_fm_modulator_fc
  parameters:
    freq_deviation: variable_qtgui_dial_control_0
    initial_phase: '0'
    samp_rate: samp_rate
  states: {}
- name: tools_upsample_xx_0
  id: tools_upsample_xx
  parameters:
    N: sps
    type: ff
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: ''
    center_freq0: 900.5e6
    dev_addr: '"serial=3102419"'
    gain0: rf_gain
    samp_rate: '240000'
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_random_uniform_source_x_0, '0', blocks_repack_bits_bb_0, '0']
- [analog_random_uniform_source_x_0, '0', tools_apsk_modulator_0, '0']
- [analog_sig_source_x_0, '0', tools_upsample_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_gfsk_mod_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_gmsk_mod_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_vector_source_x_0_0, '0', tools_apsk_modulator_0, '0']
- [digital_gfsk_mod_0, '0', pfb_synthesizer_ccf_0, '1']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [digital_gmsk_mod_0, '0', pfb_synthesizer_ccf_0, '2']
- [digital_gmsk_mod_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [digital_gmsk_mod_0, '0', qtgui_time_sink_x_0_1, '0']
- [digital_gmsk_mod_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [fft_filter_xxx_0, '0', tools_fm_modulator_fc_0, '0']
- [pfb_synthesizer_ccf_0, '0', qtgui_freq_sink_x_0_0_1, '0']
- [pfb_synthesizer_ccf_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [pfb_synthesizer_ccf_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', tools_fm_modulator_fc_0, '0']
- [rational_resampler_xxx_0_0, '0', uhd_usrp_sink_0, '0']
- [tools_apsk_modulator_0, '0', tools_upsample_xx_0, '0']
- [tools_audio_file_source_0, '0', blocks_add_xx_0, '0']
- [tools_audio_file_source_0, '1', blocks_add_xx_0, '1']
- [tools_fm_modulator_fc_0, '0', pfb_synthesizer_ccf_0, '0']
- [tools_fm_modulator_fc_0, '0', qtgui_time_sink_x_0, '0']
- [tools_fm_modulator_fc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [tools_fm_modulator_fc_0, '0', rational_resampler_xxx_0_0, '0']
- [tools_upsample_xx_0, '0', fft_filter_xxx_0, '0']

metadata:
  file_format: 1
